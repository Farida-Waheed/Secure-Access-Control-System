# Keil uVision project HomeSystem.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: HomeSystem +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c keypad.c keypad.h lcd.c lcd.h delay.c leds.h delay.h leds.c button.c button.h i2c.h i2c.c password.h password.c function.h function.c main1.c
